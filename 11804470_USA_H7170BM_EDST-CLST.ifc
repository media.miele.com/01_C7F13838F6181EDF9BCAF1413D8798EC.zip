Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 877fe258-78fb-4a53-93ff-7a7562b6da18, NumberOfSaves: 1]
File name: 0001
Time: 2024-09-05T08:51:27+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11804470_USA_H7170BM_EDST-CLST:22717046_USA_11804470_H7170BM_EDST-CLST, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_CLST, z_Miele_Design_OBSW, <Unnamed>, z_Miele_Design_Glass Black, z_Miele_Design_Zinc_Steel, z_Miele_Connection_Electric
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 757 mm; Height: 479 mm; Depth: 574 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 22717046_USA_11804470_H7170BM_EDST-CLST; sets with these values: 2
